Commit message: fix(urdf): mimic 绑定左右指

File: src/platform/dm_arm_description/urdf/DM-Arm-Description.urdf (robot description, URDF)
Before this commit: robot TRLC-DK1-Follower, 12 links, 11 joints
Joints:
- joint gripper_right: mimic (none) -> joint=gripper_left multiplier=1.0 offset=0.0
